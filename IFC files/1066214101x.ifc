Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 740c88a8-1c1e-4ec5-baa2-d7294bbb6596, NumberOfSaves: 1]
File name: Project Number
Time: 2026-07-14T12:15:38+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family14:Standard, Family14:Standard:209529
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family14
Type - Model Properties - Artikelnummer: 10662141010; Author: FV; checked by: Frank 24.01.2025; Creation Date: 25-Nov-24; Designer: frank; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX Endkappe TL-6621 links mit Abdeckkappe, Aluminium unbehandelt; OnLevel description DK: TURBOFLEX endehætte TL-6621 venstre med kasket, aluminium rå overfl.; OnLevel description EN: TURBOFLEX endcap TL-6621 left with covercap, aluminum mill finish; OnLevel description ES: TURBOFLEX tapón de acabado TL-6621 izq. con cubierta, aluminio sin tratar; OnLevel description FR: TURBOFLEX bouchon TL-6621 gauche avec couvert., aluminium non traitée; OnLevel description GB: TURBOFLEX endcap TL-6621 left with covercap, aluminum mill finish; OnLevel description NL: TURBOFLEX eindkap TL-6621 links met afdekkap, aluminium onbehandeld; OnLevel description NO: TURBOFLEX endekap TL-6621 venstre med lue, aluminium rå overflate; OnLevel description RU: TURBOFLEX плоская крышка TL-6621 оставил сучаст. крышка, oтделка алюм. mель.; OnLevel description SE: TURBOFLEX ändlock TL-6621 vänster med keps, aluminium obehand. utför.; OnLevel description US: TURBOFLEX endcap TL-6621 left with covercap, aluminum mill finish; Part Number: 10662141010; Toleranzangabe: ISO 2768 - m; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family14; Family and Type: Family14: Standard; Type: Standard; Type Id: 209514
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0123687 m2; Volume: 0.0000663538 m3
Phasing - Phase Created: New Construction
