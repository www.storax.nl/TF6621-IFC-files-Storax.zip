Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 90dd8255-93e2-496c-ada9-0359da125a8f, NumberOfSaves: 1]
File name: Project Number
Time: 2025-07-02T14:21:41+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family16:Standard, Family16:Standard:209535
In: Level 1
Type - Material: Aluminum - Flat(1)
Type - Other - Category: Generic Models; Family Name: Family16
Type - Model Properties - Artikelnummer: 10662146110; Author: NW; Comments: Rev 02 : Change the width from 79mm 78mm; Creation Date: 1/13/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX TL-6621 Endkappe rechts mit Abdeckkappe Treppe Aufg. Aluminium unbehandelt; OnLevel description Dk: TURBOFLEX TL-6621 Endekappe højre med dækkappe til trappe rå aluminium; OnLevel description EN: TURBOFLEX TL-6621 endcap right with covercap for stairway aluminum mill finish; OnLevel description ES: TURBOFLEX TL-6621 tapón de acabado der. con cubierta para escaleras aluminio sin tratar; OnLevel description FR: TURBOFLEX TL-6621 bouchon droite avec couvert. pour les escaliers aluminium non traitée; OnLevel description GB: TURBOFLEX TL-6621 endcap right with covercap for stairway aluminum mill finish; OnLevel description NL: TURBOFLEX TL-6621 eindkap rechts met afdekkap trap opgang aluminium onbehandeld; OnLevel description NO: TURBOFLEX TL-6621 Endelokk høyre med dekkappe for trappe rå aluminium; OnLevel description RU: TURBOFLEX TL-6621 плоская крышка правильно сучаст. крышка Для лестницы oтделка алюм. mель.; OnLevel description SE: TURBOFLEX TL-6621 Ändlock höger med täckprofil för trappa, aluminium obehand. utför.; OnLevel description US: TURBOFLEX TL-6621 endcap right with covercap for stairway aluminum mill finish; Part Number: 10662146110; Revisionsnummer: 02; Title: 10662146110; Toleranzangabe: ISO 2768 - m; toleranzangage: ISO 2768-m; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family16; Family and Type: Family16: Standard; Type: Standard; Type Id: 209520
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0185219 m2; Volume: 0.0000348207 m3
Phasing - Phase Created: New Construction
