Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: d40a3689-7e52-4fa5-b10e-4c1c792f0968, NumberOfSaves: 1]
File name: Project Number
Time: 2026-05-22T10:51:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:209534
In: Level 1
Type - Material: Aluminium - flach_1
Type - Other - Category: Generic Models; Family Name: Family2
Type - Model Properties - Änderungsgrund: wall thickness increased; Artikelnummer: 10662100210; Author: FV; Creation Date: 24-Jul-25; Designer: FV; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX Glas Profil 1.0kN Wandmontage TL-6621 L=2500mm, Aluminium unbehandelt; OnLevel description DK: TURBOFLEX Glasprofil 1,0kN sidemontering TL-6621 L=2500mm, aluminium rå overfl.; OnLevel description EN: TURBOFLEX glass profile 1.0kN side mount TL-6621 L=2500mm, aluminum mill finish; OnLevel description ES: TURBOFLEX perfil de vidrio 1.0kN lateralmente montaje TL-6621 L=2500mm, aluminio sin tratar; OnLevel description FR: TURBOFLEX profil verre 1.0kN latéralement montage TL-6621 L=2500mm, aluminium non traitée; OnLevel description GB: TURBOFLEX glass profile 1.0kN side mount TL-6621 L=2500mm, aluminum mill finish; OnLevel description NL: TURBOFLEX glas profiel 1.0kN wandmontage TL-6621 L=2500mm, aluminium onbehandeld; OnLevel description NO: TURBOFLEX glassprofil 1.0kN side montering TL-6621 L=2500mm, aluminium rå overflate; OnLevel description RU: TURBOFLEX профиль стекла 1.0kN сбоку монтажный TL-6621 L=2500mm, oтделка алюм. mель.; OnLevel description SE: TURBOFLEX glasprofil 1.0kN sidomontering TL-6621 L=2500mm, aluminium obehand. utför.; OnLevel description US: TURBOFLEX glass profile 1.0kN side mount TL-6621 L=2500mm, aluminum mill finish; Part Number: 10662100210; Revision Number: 04; Revisionsnummer: 04; Title: 10662100210; Toleranzangabe: DIN EN 12020-2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 209519
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.70277 m2; Volume: 0.0147129 m3
Phasing - Phase Created: New Construction
