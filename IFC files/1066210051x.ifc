Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ffeb02a7-84b2-456d-ac88-b2b2aa6e332e, NumberOfSaves: 1]
File name: Project Number
Time: 2026-05-21T15:54:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family39:Standard, Family39:Standard:209534
In: Level 1
Type - Material: Aluminium - flach_1
Type - Other - Category: Generic Models; Family Name: Family39
Type - Model Properties - Änderungsgrund: wall thickness increased; Artikelnummer: 10662100510; Author: IOL; Creation Date: 20-May-24; Designer: IOL; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX TL-6621 Glasprofil 1.0kN/1.5kN Seitenmontage L=5000mm Aluminium unbehandelt; OnLevel description DK: TURBOFLEX TL-6621 Glasprofil 1.0kN/1.5kN sidemontering L=5000mm rå aluminium; OnLevel description EN: TURBOFLEX TL-6621 glass profile 1.0kN/1.5kN side mount L=5000mm aluminum mill finish; OnLevel description ES: TURBOFLEX TL-6621 perfil de vidrio 1.0kN/1.5kN lateralmente montaje L=5000mm aluminio sin tratar; OnLevel description FR: TURBOFLEX TL-6621 profil verre 1.0kN/1.5kN latéralement montage L=5000mm aluminium non traitée; OnLevel description GB: TURBOFLEX TL-6621 glass profile 1.0kN/1.5kN side mount L=5000mm aluminum mill finish; OnLevel description NL: TURBOFLEX TL-6621 glas profiel 1.0kN/1.5kN wandmontage L=5000mm aluminium onbehandeld; OnLevel description NO: TURBOFLEX TL-6621 Glassprofil 1.0kN/1.5kN sidemontering L=5000mm rå aluminium; OnLevel description RU: TURBOFLEX TL-6621 профиль стекла 1.0kN/1.5kN сбоку монтажный L=5000mm oтделка алюм. mель.; OnLevel description SE: TURBOFLEX TL-6621 Glasprofil 1.0kN/1.5kN sidomonterad L=5000mm aluminium obehand. utför.; OnLevel description US: TURBOFLEX TL-6621 glass profile 1.0kN/1.5kN side mount L=5000mm aluminum mill finish; Part Number: 10662100510; Revision Number: 04; Revisionsnummer: 04; Title: 10662100510; Toleranzangabe: DIN EN 12020-2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family39; Family and Type: Family39: Standard; Type: Standard; Type Id: 209519
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.39905 m2; Volume: 0.0305506 m3
Phasing - Phase Created: New Construction
