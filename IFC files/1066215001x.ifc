Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 2b782002-3d68-4c6e-af02-532143b74c27, NumberOfSaves: 1]
File name: Project Number
Time: 2026-07-30T14:49:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family44:Standard, Family44:Standard:209535
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family44
Type - Model Properties - Änderungsgrund: change design to spacer TL-6051; Artikelnummer: 10662150010; Author: NH; Creation Date: 21-Apr-22; Designer: NH; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX TL-6621 Abstandshalter Stärke 15mm Aluminium unbehandelt; OnLevel description DK: TURBOFLEX TL-6621 Afstandsstykke tykkelse 15mm rå aluminium; OnLevel description EN: TURBOFLEX TL-6621 spacer Thickness 15mm aluminum mill finish; OnLevel description ES: TURBOFLEX TL-6621 espaciador Espesor 15mm aluminio sin tratar; OnLevel description FR: TURBOFLEX TL-6621 entretoise Épaisseur 15mm aluminium non traitée; OnLevel description GB: TURBOFLEX TL-6621 spacer Thickness 15mm aluminum mill finish; OnLevel description NL: TURBOFLEX TL-6621 afstandhouder Dikte 15mm aluminium onbehandeld; OnLevel description NO: TURBOFLEX TL-6621 Avstandsstykke tykkelse 15mm rå aluminium; OnLevel description RU: TURBOFLEX TL-6621 pаспорка Толщина 15mm oтделка алюм. mель.; OnLevel description SE: TURBOFLEX TL-6621 Distansstycke tjocklek 15 mm, aluminium obehand. utför.; OnLevel description US: TURBOFLEX TL-6621 spacer Thickness 15mm aluminum mill finish; Part Number: 10662150010; Revision Number: 02; Revisionsnummer: 02; Title: 10662150010; Toleranzangabe: DIN EN 12020 - 2; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family44; Family and Type: Family44: Standard; Type: Standard; Type Id: 209520
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0158703 m2; Volume: 0.000173938 m3
Phasing - Phase Created: New Construction
