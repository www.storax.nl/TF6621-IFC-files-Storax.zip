Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 16ca53ac-9de6-4ed4-a10b-51320e61dc0a, NumberOfSaves: 1]
File name: Project Number
Time: 2025-07-02T14:06:57+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family10:Standard, Family10:Standard:209527
In: Level 1
Type - Material: Aluminum - Flat-1
Type - Other - Category: Generic Models; Family Name: Family10
Type - Model Properties - Artikelnummer: 10662120510; Author: IOL; Creation Date: 5/21/2024; Designer: IOL; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX Abdeckkappe TL-6621 L=5000mm, Aluminium unbehandelt; OnLevel description DK: TL-6621 TURBOFLEX Dækkappe L=5000mm, rå aluminium; OnLevel description EN: TURBOFLEX Covercap TL-6621 L=5000mm, aluminum mill finish; OnLevel description ES: TURBOFLEX Cubierta TL-6621 L=5000mm, aluminio sin tratar; OnLevel description FR: TURBOFLEX Couverture TL-6621 L=5000mm, aluminium non traitée; OnLevel description GB: TURBOFLEX Covercap TL-6621 L=5000mm, aluminum mill finish; OnLevel description NL: TURBOFLEX Afdekkap TL-6621 L=5000mm, aluminium onbehandeld; OnLevel description NO: TL-6621 TURBOFLEX Dekklokk L=5000mm, rå aluminium; OnLevel description RU: TURBOFLEX Крышка TL-6621 L=5000mm, oтделка алюм. mель.; OnLevel description SE: TL-6621 TURBOFLEX Täcklock L=5000mm, rå aluminium; OnLevel description US: TURBOFLEX Covercap TL-6621 L=5000mm, aluminum mill finish; Part Number: 10662120510; Title: 10662120510; Toleranzangabe: DIN EN 12020-2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family10; Family and Type: Family10: Standard; Type: Standard; Type Id: 209512
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.12334 m2; Volume: 0.00190691 m3
Phasing - Phase Created: New Construction
