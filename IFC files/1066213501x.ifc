Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: eaf126d5-bbe8-4b1b-a906-96718b40c933, NumberOfSaves: 1]
File name: Project Number
Time: 2026-05-21T15:38:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family36:Standard, Family36:Standard:209544
In: Level 1
Type - Material: Aluminium - flach_1
Type - Other - Category: Generic Models; Family Name: Family36
Type - Model Properties - Artikelnummer: 10662135010; Author: NW; Breite: 0; Creation Date: 21-Nov-24; Designer: NW; Design State: 1; Gewicht: 0; Höhe: 0; Länge: 0; Oberfläche: mill finish; OnLevel description DE: TF-6621 Außenecke 90°, Aluminium unbehandelt; OnLevel description DK: TF-6621 udv. hjørne 90°, aluminium rå overfl.; OnLevel description EN: TF-6621 outside corner 90°, aluminum mill finish; OnLevel description ES: TF-6621 esquina exterior 90°, aluminio sin tratar; OnLevel description FR: TF-6621 angle extérieur 90°, aluminium non traitée; OnLevel description GB: TF-6621 outside corner 90°, aluminum mill finish; OnLevel description NL: TF-6621 buitenhoek 90°, aluminium onbehandeld; OnLevel description NO: TF-6621 utvendig hjørne 90°, aluminium rå overflate; OnLevel description RU: TF-6621 внешний угол 90 °, oтделка алюм. mель.; OnLevel description SE: TF-6621 utsida hörna 90°, aluminium obehand. utför.; OnLevel description US: TF-6621 outside corner 90°, aluminum mill finish; Part Number: S-10662135010; Revision Number: 04; Revisionsnummer: 04; Title: 10662135010; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family36; Family and Type: Family36: Standard; Type: Standard; Type Id: 209529
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.102994 m2; Volume: 0.00213981 m3
Phasing - Phase Created: New Construction
